# Keil uVision project count.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: count +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h Display.c Display.h Timer.c Timer.h Key.c Key.h EEPROM.c EEPROM.h Data.c Data.h Product.c Product.h
